# Keil uVision project engineering.uvprojx, settings and files
target ENGINEER (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: engineering.elf +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__FPU_PRESENT=1,USE_USB_OTG_FS,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --no-multibyte-chars
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER_CONF;..\BSP_CONF;..\TASK;..\FUNTION;..\PROTOCOL;.\include;..\BMI088\algorithm;..\BMI088\devices;..\BMI088\rm_lib;..\USB_LIB\STM32_USB_Device_Library\Class\cdc\inc;..\USB_LIB\STM32_USB_Device_Library\Core\inc;..\USB_LIB\STM32_USB_OTG_Driver\inc;..\IST8310
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c STM32_TIM_BASE.c arm_cortexM4lf_math.lib usbd_desc.c usbd_usr.c
    ../USER_CONF/: start_tack.c
  group CORE
    ../CORE/: startup_stm32f407xx.s core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group User_conf
    ../USER_CONF/: delay.c gpio.c can.c usart.c spi.c rc.c dma.c tim.c sys_config.h st_usb_cdc.c I2C.c iwdg.c
  group Bsp_device
    ../BSP_CONF/: bsp_can.c bsp_flash.c bsp_dwt.c bsp_imu.c bsp_usb.c
  group Task
    ../TASK/: chassis_task.c comm_task.c detect_task.c gimbal_task.c info_get_task.c judge_task.c modeswitch_task.c pc_task.c shoot_task.c imu_task.c
  group Funtion
    ../FUNTION/: fuzzy_pid.c kalman_filter.c remote_ctrl.c keyboard.c ramp.c pid.c ladrc.c power_control.c pid_controller.c filter.c
  group Protocol
    ../PROTOCOL/: protocol.c data_fifo.c data_packet.c judge_rx_data.c judge_tx_data.c pc_rx_data.c pc_tx_data.c bsp_vofa.c
  group BMI088
    ../BMI088/devices/: BMI088driver.c BMI088Middleware.c
    ../BMI088/algorithm/: AHRS_middleware.c AHRS.lib
  group IST8310
    ../IST8310/: IST8310.c IST8310.h IST8310reg.h
  group USB_CDC
    ../USB_LIB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
    ../USB_LIB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB_LIB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
