# Keil uVision project engineering.uvprojx, settings and files
target ENGINEER (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: engineering +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,ARM_MATH_CM4,__FPU_PRESENT=1,__TARGET_FPU_VFP,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USER_CONF;..\BSP_CONF;..\TASK;..\FUNTION;..\PROTOCOL;.\include;..\BMI088;..\BMI088\algorithm\Include;..\BMI088\devices;..\BMI088\algorithm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c STM32_TIM_BASE.c arm_cortexM4lf_math.lib User.h
    ../USER_CONF/: start_task.c
  group Bsp_device
    ../BSP_CONF/: bsp_can.c bsp_flash.c bsp_trigonometry.c bsp_dwt.c bsp_dwt.h
  group BMI088
    ../BMI088/devices/: BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h struct_typedef.h
    ../BMI088/algorithm/: AHRS_middleware.c filters.c MahonyAHRS.c AHRS.h AHRS.lib
  group Task
    ../TASK/: chassis_task.c modeswitch_task.c gimbal_task.c info_get_task.c upraise_task.c clamp_task.c detect_task.c supply_task.c judge_task.c slide_task.c rescue_task.c barrier_carry_task.c manipulator_task.c controller.c motor_task.c imu_task.c imu_task.h comm_8010_task.c comm_8010_task.h
  group Protocol
    ../TASK/: comm_task.c
    ../PROTOCOL/: protocol.c data_fifo.c data_packet.c judge_rx_data.c judge_tx_data.c pc_rx_data.c pc_tx_data.c crc.c crc.h motor_8010.c motor_8010.h
  group Funtion
    ../TASK/: pc_task.c
    ../FUNTION/: fuzzy_pid.c kalman_filter.c keyboard.c remote_ctrl.c ramp.c pid.c clamp.c
    ./: filter.c
  group User_conf
    ../USER_CONF/: delay.c gpio.c can.c usart.c spi.c rc.c dma.c tim.c sys_config.h
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
